# Repository djtersteegc/fujinet-devkit-shield

File README.md:

# fujinet-devkit-shield

This is an alternative hardware platform for [FujiNet](https://fujinet.online/) that allows you to build your own using all through-hole technology (THT) components and an Espressif ESP32-DevKitC-VE devkit board.  You could probably also use a ESP32-DevKitC-VIE board, but you will need to either use an external IPEX connected antenna or engage in some micro soldering since the on-board PCB antenna is not connected by default. You must use ESP32-WROVER based devkit boards, the cheaper ESP32-WROOM boards lack the PSRAM needed by FujiNet code these days. 

The PCB is designed for flexibility in building, with different cabling options and headers for the buttons and LEDs if you want to mount this in your own enclosure. Most components are "jelly bean" parts you may already have or can be purchased for one or two cents in quantity from the usual China based suppliers.  Total cost of the build should be around $20, depending on where you source your parts.  Please see the assembly page for more details.

[Hardware Component Choices and Assembly](https://djtersteegc.github.io/fujinet-devkit-shield/assembly.html)

An interactive BOM and parts placement diagram is also available.

[Interactive Bill of Materials (BOM)](https://djtersteegc.github.io/fujinet-devkit-shield/ibom.html)

Currently this board is not supported by the FujiNet updater app so you will need to use Platform IO to build and upload your own binaries.  Build with the 8MB flash target since the devkit boards have half the flash of the 16MB WROVER modules used on the SIO mounted FujiNet designed by [mozzwald](https://github.com/mozzwald).  In normal operation is should not really matter since 6MB in the 16MB version is currently reserved for over the air (OTA) updates and the release build uses a little more than 2MB of flash as of March 2021 so lots of free space still for future development.

[Board bring up for FujiNet Platform.IO code](https://github.com/FujiNetWIFI/fujinet-platformio/wiki/Board-bring-up-for-FujiNet-Platform.IO-code)

STL's and the [DesignSpark Mechanical](https://www.rs-online.com/designspark/mechanical-software) source file for a 3D printable enclosure are in the **enclosure** directory. Assemble with four M3x10mm screws. Make sure to print 3 copies of the button file.

# Getting a Board

If I have extra PCB's, they will be listed on Tindie.

[https://www.tindie.com/products/tersteeg/fujinet-devkit-shield/](https://www.tindie.com/products/tersteeg/fujinet-devkit-shield/)

Otherwise you can download the Gerbers and use your favorite fab (JLCPCB, PCBWay, etc.) to make your own batch.  It's a standard two layer, 1oz copper board with dimensions of 99mm x 56mm so it squeaks under the 100mm x 100mm limit of the cheap Chinese fabs.

# Hardware Revisions

### Version 1.0

Mostly tested. Standard pin header cable with the SMD MicroSD card connector works.  Still waiting for DB15 connectors to test that cable configuration and a 4.7uf ceramic cap for audio in line. Will also build that one with the micro SD breakout board to verify.  External pin headers for the buttons and LEDs are also untested, but should work. Equivalent to version 1.3+ (pull-up resistors on the SIO and SD card lines) of the SIO port mounted FujiNet.

## KiCad design fujinet-devkit-shield.kicad_pcb

Parts:
C1: 4.7uF 6.3V; C_Disc_D5.1mm_W3.2mm_P5.00mm
C2, C3: 0.1uf; C_Disc_D5.0mm_W2.5mm_P5.00mm
C4: 10uF 6.3V; CP_Radial_Tantal_D5.5mm_P5.00mm
C5: 10uf 6.3V; CP_Radial_D6.3mm_P2.50mm
D1: WIFI; LED_D5.0mm
D2: SIO; LED_D5.0mm
D3: BLUETOOTH; LED_D5.0mm
D4: 1N5817; D_DO-41_SOD81_P10.16mm_Horizontal
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: SIO (No 12V); PinHeader_1x12_P2.54mm_Vertical
J2: Conn_BUTTON_A; PinHeader_1x02_P2.54mm_Vertical
J3: SD BOARD; PinHeader_1x06_P2.54mm_Vertical
J4: Conn_BUTTON_B; PinHeader_1x02_P2.54mm_Vertical
J5: Conn_BUTTON_RESET; PinHeader_1x02_P2.54mm_Vertical
J6: Conn_WHITE_LED; PinHeader_1x02_P2.54mm_Vertical
J7: Conn_ORANGE_LED; PinHeader_1x02_P2.54mm_Vertical
J8: Conn_BLUE_LED; PinHeader_1x02_P2.54mm_Vertical
J10: DB15_Female_MountingHoles; DSUB-15_Female_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_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
P1: ST-TF-003A; SUNTECH_ST-TF-003A
R1, R3: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 1.2K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4, R5, R6, R8, R9, R10, R11, R12, R13: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R14: 2K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R15: 3.9K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R16: 4.7K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: BUTTON A; SW_TH_Tactile_Omron_B3F-10xx
SW2: BUTTON B; SW_TH_Tactile_Omron_B3F-10xx
SW3: RESET; SW_TH_Tactile_Omron_B3F-10xx
U1: ESP32-DEVKITC-VE; MODULE_ESP32-DEVKITC-32U; PARTREV N/A
U3, U4: SN74LS07N; DIP-14_W7.62mm_Socket_LongPads

Connections:
+3V3: C4.1, D1.2 (A), D2.2 (A), D3.2 (A), J3.1, J6.1, J7.1, J8.1, P1.4 (VDD), R5.2, R6.2, R8.2, R9.1, R10.2, R11.2, R12.2, R13.2, U1.1 (3V3)
+5V: C2.1, C3.1, C5.1, D4.1, R14.2, R16.2, U1.19 (EXT_5V), U3.14 (VCC), U4.14 (VCC)
GND: C2.2, C3.2, C4.2, C5.2, J1.4, J1.6, J2.1, J3.6, J4.1, J5.1, J10.4, J10.6, P1.6 (VSS), P1.G1 (GND), P1.G2 (GND), P1.G3 (GND), P1.G4 (GND), R4.2, R15.1, SW1.4 (A), SW2.4 (A), SW3.4 (A), U1.14 (GND1), U1.32 (GND2), U1.38 (GND3), U3.1, U3.3, U3.5, U3.7 (GND), U3.13, U4.1, U4.7 (GND)
IO0_BUTTON_A: J2.2, R9.2, SW1.1, U1.25 (IO0)
IO2_LED1: R1.2, U1.24 (IO2)
IO3_LED3: R3.2, U1.15 (IO13)
IO4_LED2: R2.2, U1.26 (IO4)
IO5_SPI_CS: J3.2, P1.2 (DAT3), R13.1, U1.29 (IO5)
IO14_BUTTON_RESET: J5.2, R8.1, SW3.1, U1.12 (IO14)
IO18_SPI_CLK: J3.4, P1.5 (CLK), R11.1, U1.30 (IO18)
IO19_SPI_MISO: J3.5, P1.7 (DAT0), R10.1, U1.31 (IO19)
IO21_DATAIN: U1.33 (IO21), U3.9
IO22_PROC: U1.36 (IO22), U3.11
IO23_SPI_MOSI: J3.3, P1.3 (CMD), R12.1, U1.37 (IO23)
IO25_AUDIOIN: R7.1, U1.9 (IO25)
IO26_INT: U1.10 (IO26), U4.3
IO27_CKIN: U1.11 (IO27), U4.5
IO32_CKOUT: U1.7 (IO32), U4.10
IO33_DATAOUT: U1.8 (IO33), U4.8
IO34_BUTTON_B: J4.2, R5.1, SW2.1, U1.5 (IO34)
IO35_SIO_VOLTAGE: R14.1, R15.2, U1.6 (IO35)
IO39_CMD: R6.1, U1.4 (SENSOR_VN), U4.12
unnamed: C1.2, R7.2
unnamed: D1.1 (K), J6.2, R1.1
unnamed: D2.1 (K), J7.2, R2.1
unnamed: D3.1 (K), J8.2, R3.1
SIO_5V: D4.2, J1.10, J10.10
SIO_AUDIOIN: C1.1, J1.11, J10.11
SIO_CKIN: J1.1, J10.1, U4.6
SIO_CKOUT: J1.2, J10.2, U4.11
SIO_CMD: J1.7, J10.7, U4.13
SIO_DATAIN: J1.3, J10.3, R16.1, U3.8
SIO_DATAOUT: J1.5, J10.5, U4.9
SIO_INT: J1.12, J10.13, U4.4
SIO_MCTL: J1.8, J10.8, R4.1, U1.3 (SENSOR_VP)
SIO_PROC: J1.9, J10.9, U3.10

Board: 2 copper layers, 99.1 x 55.9 mm, 45 parts (0 on the bottom side), 36 nets.

## Commit log

2021-02-11 Add exported schematic and board render
2021-02-27 Files sent to JCL
2021-02-27 Remove old board image
2021-03-04 First pass at some docs
2021-03-04 update docs
2021-03-04 Add image
2021-03-04 More docs update
2021-03-04 doc updates
2021-03-10 Update README.md
    Add Tindie link
2022-10-21 Fixup 3D models
2022-10-21 Add enclosure files
